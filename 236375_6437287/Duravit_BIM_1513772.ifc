Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Basins_DURAVIT_236375-Sink.ifc
Time: 2021-04-23T16:10:56
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: 236375 Sink
ePset_BIMobjectScript - Color: 00 White Alpin; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): 236375 Sink; SKU (BO_prodsku): white-tulip-sink-236375; ManufacturName (BO_Manufac): DURAVIT; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): White Tulip; ProductGroup (BO_prodgroup): Sinks; EditionNumber (BO_edinum): 1; Width (BO_width): 750; Height (BO_height): 155; Depth (BO_depth): 490; Weight (BO_weight): 21.5; QR (BO_boqrurl): http://bimobject.com/duravit/product/white-tulip-sink-236375; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/white-tulip-sink-236375; ProductUrl (BO_producturl): https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/4/Duravit_PI-HI_2363750000_23637500001__1415187.jpg; TechnicalDescription (BO_techcert): https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/2/Duravit_TD_236375_V_2__1258687.jpg | https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/2/Duravit_TD_236375_V_1__1258686.jpg | https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/2/Duravit_TD_i_236375_D_1__1258699.jpg | https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/2/Duravit_TD_i_236375_D_2__1258700.jpg | https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/2/Duravit_TD_i_236375_V_1__1258701.jpg | https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/2/Duravit_TD_i_236375_V_2__1258702.jpg | https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/2/Duravit_TD_236375_D_2__1258685.jpg | https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/2/Duravit_TD_236375_D_1__1258684.jpg; GtinCode (BO_gtin): 4053424913575; MaterialMain (BO_mainmat): Ceramics; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Basins; BimObjectCategoryCode (BO_bocat_code): sanitary-basins; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspscCode (BO_unspsc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L721; Uniclass14Description (BO_uniclass_1_4_desc): Sanitary equipment; Uniclass20Code (BO_uniclass_2_0_code): PR-31-76; Uniclass20Description (BO_uniclass_2_0_desc): Sanitary Dispensing And Disposal Units; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_96; Uniclass2015Description (BO_uniclass2015_desc): Wash basins, sinks and troughs; NBSReference (BO_nbs_ref): 31-76; NBSReferenceDescription (BO_nbs_desc): Sanitary Dispensing And Disposal Units; OmniClassCode (BO_omniclass_code): 23-21 43 23; OmniClassDescription (BO_omniclass_name): Sanitary Waste Receptacles; MasterFormat2014Code (BO_masterformat2014_code): 22 45 26; MasterFormat2014Description (BO_masterformat2014_name): Eye/Face Wash Equipment; UniFormat2Code (BO_uniformat2_code): E1010; UniFormat2Description (BO_uniformat2_name): Commercial Equipment; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
